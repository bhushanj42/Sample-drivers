FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " \
	file://0002-add-spi-dts.patch	\
	file://0003-enable-spi-dts.patch \
"
